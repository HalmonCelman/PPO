# Keil uVision project ppo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2136/01 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ppo +hex
  c flags: Optim=1
  c misc: --cpp
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s led.cpp stepper.cpp main.cpp keyboard.cpp ledinv.cpp ledpos.cpp
